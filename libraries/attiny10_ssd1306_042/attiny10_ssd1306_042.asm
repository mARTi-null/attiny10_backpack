/***********************************************************************************************************************

 * attiny10_ssd1306_042.asm
 *
 * Created: 11.10.2026. 15:42:03
 * Author: mARTi_null

************************************************************************************************************************
MCU DATA AND PINOUT
************************************************************************************************************************

	Clock	 = 8Mhz
	Flash	 = 1024 Bytes
	SRAM	 = 32 Bytes

				 +------+
	SDA - PB0 - 1|°		|6 - PB3
		  GND - 2|		|5 - VCC (3.3V)
	SCL	- PB1 - 3|		|4 - PB2
				 +------+

************************************************************************************************************************
LIST OF OLED COMMANDS
************************************************************************************************************************

	-----OLED INIT COMMANDS-----
	0xAE				; Oled OFF
	0xD5, 0xF0			; Oled freq/divider
	0xA8, 0x27			; Multyplex Ratio 1/40 duty
	0xAD, 0x30			; Set internal IREF
	0xC8				; Scan direction, default scan C0
	0xA1				; Segment remap, default no remap A0
	0x20, 0x00			; Set Addressing mode (0x00 - Horizontal, 0x01 - Vertical, (default)0x02 - Page Addressing mode)
	0x21, 0x1C, 0x63	; Set Column address |||||||| with offset of 28
	0x22, 0x00, 0x04	; Set page address _ _ _ _
	0xDA, 0x12			; Set COM pins to sequential
	0x81, 0xAF			; Set contrast
	0xD9, 0x22			; Set precharge level F1/22
	0x8D, 0x14			; Set Charge pump enable
	0xA4				; A5 Full ON, A4 ON
	0xAF				; Oled ON

************************************************************************************************************************
INCLUDES, DEFINITIONS AND CONSTANTS
***********************************************************************************************************************/
.ifndef oled_addr
	.equ	oled_addr = 0x78
.endif

.ifndef oled_command
	.equ	oled_command = 0x00
.endif

.ifndef oled_i2c_data
	.equ	oled_i2c_data	= 0x40
.endif

.ifndef font_width
	.equ	font_width	= 3
.endif

/***********************************************************************************************************************
REGISTERS
***********************************************************************************************************************/
.ifndef tmp
    .def tmp = r16
.endif

.ifndef count_i
    .def count_i = r19
.endif

.ifndef count_j
    .def count_j = r20
.endif

.ifndef x1
    .def x1 = r21
.endif

.ifndef x2
    .def x2 = r22
.endif

.ifndef y1
    .def y1 = r23
.endif

.ifndef y2
    .def y2 = r24
.endif

/***********************************************************************************************************************
LIBRARIES
***********************************************************************************************************************/
.include "attiny10_i2c.asm"
.include "attiny10_ddb.asm"

/************************************************************************************************************************
OLED INITIALIZATION
***********************************************************************************************************************/
init_oled:
	ldi 	R19, 27									; Number of commands to send in array
	ldi		ZL, low(0x4000 + oled_commands * 2)		;
	ldi		ZH, high(0x4000 + oled_commands *2)
	rcall	start_command
send_command:
	ld		i2c_data, Z+
	rcall	i2c_send
	dec		R19
	brne	send_command
	rcall	i2c_stop
	nop
	nop
ret

/***********************************************************************************************************************
OLED I2C PROTOCOL
***********************************************************************************************************************/
start_command:
	rcall	i2c_start
	ldi		i2c_data, oled_addr
	rcall	i2c_send
	ldi		i2c_data, oled_command
	rcall	i2c_send
ret

start_data:
	rcall	i2c_start
	ldi		i2c_data, oled_addr
	rcall	i2c_send
	ldi		i2c_data, oled_i2c_data
	rcall	i2c_send
ret

/***********************************************************************************************************************
CLEAR SCREEN
***********************************************************************************************************************/
clear_screen:
	ldi		count_j, 0x02
clr_outer:
	ldi		count_i, 0xB4
clr_inner:
	ldi		i2c_data, 0x00
	rcall	i2c_send
	dec		count_i
	brne	clr_inner
	dec		count_j
	brne	clr_outer
ret

/***********************************************************************************************************************
SET CURSOR
***********************************************************************************************************************/
set_cursor:
	rcall	i2c_stop
	rcall	start_command
	ldi		i2c_data, 0x21
	rcall	i2c_send
	mov		i2c_data, x1		; Start column
	rcall	i2c_send
	mov		i2c_data, x2		; End column
	rcall	i2c_send
	ldi		i2c_data, 0x22
	rcall	i2c_send
	mov		i2c_data, y1		; Start page
	rcall	i2c_send
	mov		i2c_data, y2		; End page
	rcall	i2c_send
	rcall	i2c_stop
ret

/***********************************************************************************************************************
DRAW SINGLE ASCII CHAR FROM FONT ARRAY
***********************************************************************************************************************/
draw_char:
	rcall	get_char_pos
	ldi		r21, 0x00
	ldi		ZL, low(0x4000 + font * 2)
	ldi		ZH, high(0x4000 + font * 2)
	add		ZL, tmp
	adc		ZH, r21
	ldi		count_j, font_width
loop_text:
	ld		i2c_data, Z+
	rcall	i2c_send
	dec		count_j
	brne	loop_text
	ldi		i2c_data, 0x00
	rcall	i2c_send
ret

/***********************************************************************************************************************
OLED INIT ARRAY
***********************************************************************************************************************/

oled_commands:
.DB	0xAE, 0xD5, 0xF0, 0xA8, 0x27, 0xAD, 0x30, 0xC8, 0xA1, 0x20, 0x00, 0x21, 0x1C, 0x63
.DB 0x22, 0x00, 0x04, 0xDA, 0x12, 0x81, 0xAF, 0xD9, 0x22, 0x8D, 0x14, 0xA4, 0xAF, 0x00

/***********************************************************************************************************************
FONT ARRAY
***********************************************************************************************************************/

font:
.DB	0x00, 0x00, 0x00,/*" "*/\
	0x00, 0x2e, 0x00,/*"!"*/\
	0x06, 0x00, 0x06,/*"""*/\
	0x3e, 0x14, 0x3e,/*"#"*/\
	0x2c, 0x3e, 0x1a,/*"$"*/\
	0x32, 0x08, 0x26,/*"%"*/\
	0x34, 0x2a, 0x14,/*"&"*/\
	0x00, 0x06, 0x00,/*"'"*/\
	0x1c, 0x22, 0x00,/*"("*/\
	0x00, 0x22, 0x1c,/*")"*/\
	0x14, 0x08, 0x14,/*"*"*/\
	0x08, 0x1c, 0x08,/*"+"*/\
	0x40, 0x20, 0x00,/*","*/\
	0x08, 0x08, 0x08,/*"-"*/\
	0x00, 0x20, 0x00,/*"."*/\
	0x30, 0x08, 0x06,/*"/"*/\
	0x3e, 0x22, 0x3e,/*"0"*/\
	0x04, 0x3e, 0x00,/*"1"*/\
	0x3a, 0x2a, 0x2e,/*"2"*/\
	0x22, 0x2a, 0x3e,/*"3"*/\
	0x0e, 0x08, 0x3e,/*"4"*/\
	0x2e, 0x2a, 0x3a,/*"5"*/\
	0x3e, 0x2a, 0x3a,/*"6"*/\
	0x02, 0x02, 0x3e,/*"7"*/\
	0x3e, 0x2a, 0x3e,/*"8"*/\
	0x2e, 0x2a, 0x3e,/*"9"*/\
	0x00, 0x28, 0x00,/*":"*/\
	0x40, 0x28, 0x00,/*";"*/\
	0x08, 0x14, 0x22,/*"<"*/\
	0x14, 0x14, 0x14,/*"="*/\
	0x22, 0x14, 0x08,/*">"*/\
	0x02, 0x2a, 0x06,/*"?"*/\
	0x1c, 0x22, 0x2c,/*"@"*/\
	0x3c, 0x0a, 0x3e,/*"A"*/\
	0x3c, 0x2a, 0x16,/*"B"*/\
	0x1c, 0x22, 0x22,/*"C"*/\
	0x3e, 0x22, 0x1c,/*"D"*/\
	0x3c, 0x2a, 0x2a,/*"E"*/\
	0x3c, 0x0a, 0x0a,/*"F"*/\
	0x1c, 0x22, 0x3a,/*"G"*/\
	0x3e, 0x08, 0x3e,/*"H"*/\
	0x22, 0x3e, 0x22,/*"I"*/\
	0x10, 0x22, 0x1e,/*"J"*/\
	0x3e, 0x08, 0x36,/*"K"*/\
	0x3e, 0x20, 0x20,/*"L"*/\
	0x3e, 0x04, 0x3e,/*"M"*/\
	0x3e, 0x02, 0x3c,/*"N"*/\
	0x1c, 0x22, 0x1c,/*"O"*/\
	0x3e, 0x0a, 0x0c,/*"P"*/\
	0x1c, 0x32, 0x3c,/*"Q"*/\
	0x3c, 0x0a, 0x36,/*"R"*/\
	0x24, 0x2a, 0x12,/*"S"*/\
	0x02, 0x3e, 0x02,/*"T"*/\
	0x1e, 0x20, 0x3e,/*"U"*/\
	0x1e, 0x20, 0x1e,/*"V"*/\
	0x3e, 0x10, 0x3e,/*"W"*/\
	0x36, 0x08, 0x36,/*"X"*/\
	0x06, 0x38, 0x06,/*"Y"*/\
	0x32, 0x2a, 0x26,/*"Z"*/\
	0x3e, 0x22, 0x00,/*"["*/\
	0x06, 0x08, 0x30,/*"\"*/\
	0x22, 0x3e, 0x00,/*"]"*/\
	0x04, 0x02, 0x04,/*"^"*/\
	0x20, 0x20, 0x20,/*"_"*/\
	0x02, 0x04, 0x00,/*"`"*/\
	0x18, 0x24, 0x3c,/*"a"*/\
	0x3e, 0x28, 0x38,/*"b"*/\
	0x18, 0x24, 0x24,/*"c"*/\
	0x38, 0x28, 0x3e,/*"d"*/\
	0x18, 0x34, 0x2c,/*"e"*/\
	0x3c, 0x12, 0x04,/*"f"*/\
	0x48, 0x54, 0x38,/*"g"*/\
	0x3e, 0x08, 0x30,/*"h"*/\
	0x00, 0x1a, 0x20,/*"i"*/\
	0x00, 0x40, 0x34,/*"j"*/\
	0x3e, 0x08, 0x34,/*"k"*/\
	0x00, 0x1e, 0x20,/*"l"*/\
	0x3c, 0x08, 0x3c,/*"m"*/\
	0x3c, 0x04, 0x38,/*"n"*/\
	0x18, 0x24, 0x18,/*"o"*/\
	0x7c, 0x24, 0x18,/*"p"*/\
	0x18, 0x24, 0x7c,/*"q"*/\
	0x3c, 0x08, 0x04,/*"r"*/\
	0x28, 0x2c, 0x14,/*"s"*/\
	0x1e, 0x24, 0x20,/*"t"*/\
	0x1c, 0x20, 0x3c,/*"u"*/\
	0x3c, 0x20, 0x1c,/*"v"*/\
	0x3c, 0x10, 0x3c,/*"w"*/\
	0x34, 0x08, 0x34,/*"x"*/\
	0x0c, 0x50, 0x3c,/*"y"*/\
	0x24, 0x34, 0x2c,/*"z"*/\
	0x08, 0x3e, 0x22,/*"{"*/\
	0x00, 0x3e, 0x00,/*"|"*/\
	0x22, 0x3e, 0x08,/*"}"*/\
	0x08, 0x18, 0x10,/*"~"*/\
	0x00, 0x00, 0x00/*" "*/

; COPY AND UNCOMMENT CHARACTER BYTE ROW YOU WANT TO USE FROM ASCII TABLE BELOW
; LEAVE "\"AT THE END OF EVERY LINE AND DELETE "," AND "/" ON THE LAST LINE

;----ASCII CHARACTER ARRAY----;
	;0x00, 0x00, 0x00,/*" "*/\
	;0x00, 0x2e, 0x00,/*"!"*/\
	;0x06, 0x00, 0x06,/*"""*/\
	;0x3e, 0x14, 0x3e,/*"#"*/\
	;0x2c, 0x3e, 0x1a,/*"$"*/\
	;0x32, 0x08, 0x26,/*"%"*/\
	;0x34, 0x2a, 0x14,/*"&"*/\
	;0x00, 0x06, 0x00,/*"'"*/\
	;0x1c, 0x22, 0x00,/*"("*/\
	;0x00, 0x22, 0x1c,/*")"*/\
	;0x14, 0x08, 0x14,/*"*"*/\
	;0x08, 0x1c, 0x08,/*"+"*/\
	;0x40, 0x20, 0x00,/*","*/\
	;0x08, 0x08, 0x08,/*"-"*/\
	;0x00, 0x20, 0x00,/*"."*/\
	;0x30, 0x08, 0x06,/*"/"*/\
	;0x3e, 0x22, 0x3e,/*"0"*/\
	;0x04, 0x3e, 0x00,/*"1"*/\
	;0x3a, 0x2a, 0x2e,/*"2"*/\
	;0x22, 0x2a, 0x3e,/*"3"*/\
	;0x0e, 0x08, 0x3e,/*"4"*/\
	;0x2e, 0x2a, 0x3a,/*"5"*/\
	;0x3e, 0x2a, 0x3a,/*"6"*/\
	;0x02, 0x02, 0x3e,/*"7"*/\
	;0x3e, 0x2a, 0x3e,/*"8"*/\
	;0x2e, 0x2a, 0x3e,/*"9"*/\
	;0x00, 0x28, 0x00,/*":"*/\
	;0x40, 0x28, 0x00,/*";"*/\
	;0x08, 0x14, 0x22,/*"<"*/\
	;0x14, 0x14, 0x14,/*"="*/\
	;0x22, 0x14, 0x08,/*">"*/\
	;0x02, 0x2a, 0x06,/*"?"*/\
	;0x1c, 0x22, 0x2c,/*"@"*/\
	;0x3c, 0x0a, 0x3e,/*"A"*/\
	;0x3c, 0x2a, 0x16,/*"B"*/\
	;0x1c, 0x22, 0x22,/*"C"*/\
	;0x3e, 0x22, 0x1c,/*"D"*/\
	;0x3c, 0x2a, 0x2a,/*"E"*/\
	;0x3c, 0x0a, 0x0a,/*"F"*/\
	;0x1c, 0x22, 0x3a,/*"G"*/\
	;0x3e, 0x08, 0x3e,/*"H"*/\
	;0x22, 0x3e, 0x22,/*"I"*/\
	;0x10, 0x22, 0x1e,/*"J"*/\
	;0x3e, 0x08, 0x36,/*"K"*/\
	;0x3e, 0x20, 0x20,/*"L"*/\
	;0x3e, 0x04, 0x3e,/*"M"*/\
	;0x3e, 0x02, 0x3c,/*"N"*/\
	;0x1c, 0x22, 0x1c,/*"O"*/\
	;0x3e, 0x0a, 0x0c,/*"P"*/\
	;0x1c, 0x32, 0x3c,/*"Q"*/\
	;0x3c, 0x0a, 0x36,/*"R"*/\
	;0x24, 0x2a, 0x12,/*"S"*/\
	;0x02, 0x3e, 0x02,/*"T"*/\
	;0x1e, 0x20, 0x3e,/*"U"*/\
	;0x1e, 0x20, 0x1e,/*"V"*/\
	;0x3e, 0x10, 0x3e,/*"W"*/\
	;0x36, 0x08, 0x36,/*"X"*/\
	;0x06, 0x38, 0x06,/*"Y"*/\
	;0x32, 0x2a, 0x26,/*"Z"*/\
	;0x3e, 0x22, 0x00,/*"["*/\
	;0x06, 0x08, 0x30,/*"\"*/\
	;0x22, 0x3e, 0x00,/*"]"*/\
	;0x04, 0x02, 0x04,/*"^"*/\
	;0x20, 0x20, 0x20,/*"_"*/\
	;0x02, 0x04, 0x00,/*"`"*/\
	;0x18, 0x24, 0x3c,/*"a"*/\
	;0x3e, 0x28, 0x38,/*"b"*/\
	;0x18, 0x24, 0x24,/*"c"*/\
	;0x38, 0x28, 0x3e,/*"d"*/\
	;0x18, 0x34, 0x2c,/*"e"*/\
	;0x3c, 0x12, 0x04,/*"f"*/\
	;0x48, 0x54, 0x38,/*"g"*/\
	;0x3e, 0x08, 0x30,/*"h"*/\
	;0x00, 0x1a, 0x20,/*"i"*/\
	;0x00, 0x40, 0x34,/*"j"*/\
	;0x3e, 0x08, 0x34,/*"k"*/\
	;0x00, 0x1e, 0x20,/*"l"*/\
	;0x3c, 0x08, 0x3c,/*"m"*/\
	;0x3c, 0x04, 0x38,/*"n"*/\
	;0x18, 0x24, 0x18,/*"o"*/\
	;0x7c, 0x24, 0x18,/*"p"*/\
	;0x18, 0x24, 0x7c,/*"q"*/\
	;0x3c, 0x08, 0x04,/*"r"*/\
	;0x28, 0x2c, 0x14,/*"s"*/\
	;0x1e, 0x24, 0x20,/*"t"*/\
	;0x1c, 0x20, 0x3c,/*"u"*/\
	;0x3c, 0x20, 0x1c,/*"v"*/\
	;0x3c, 0x10, 0x3c,/*"w"*/\
	;0x34, 0x08, 0x34,/*"x"*/\
	;0x0c, 0x50, 0x3c,/*"y"*/\
	;0x24, 0x34, 0x2c,/*"z"*/\
	;0x08, 0x3e, 0x22,/*"{"*/\
	;0x00, 0x3e, 0x00,/*"|"*/\
	;0x22, 0x3e, 0x08,/*"}"*/\
	;0x08, 0x18, 0x10,/*"~"*/\
	;0x00, 0x00, 0x00/*" "*/
